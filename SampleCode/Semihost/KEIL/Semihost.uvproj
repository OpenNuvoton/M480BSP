# Keil uVision project Semihost.uvproj, settings and files
target Semihost (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
