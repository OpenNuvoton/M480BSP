# IAR project emWin_SimpleDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\emWin\Include; ..\..\..\..\ThirdParty\emWin\Config; ..\..\..\..\ThirdParty\FatFs\source; ..\tslib
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emWin_SimpleDemo.bin
  ILINK.IlinkOutputFile: emWin_SimpleDemo.out
  ILINK.IlinkIcfFile: emWin_SimpleDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../Application/: FramewinDLG.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM4_IAR.a
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c eadc.c ebi.c fmc.c gpio.c retarget.c sdh.c sys.c timer.c uart.c
  group tslib
    ../tslib/: diskio.c fbutils.c M48XTouchPanel.c SDGlue.c testutils.c ts_calibrate.c
  group User
    ../: main.c
