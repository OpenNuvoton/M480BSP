# Keil uVision project emWin_GUIDemo.uvproj, settings and files
target emWin_GUIDemo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: emWin_GUIDemo
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\tslib;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
--diag_suppress=L6329
  group Libraries
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../../../../Library/StdDriver/src/: eadc.c ebi.c gpio.c retarget.c sdh.c sys.c timer.c uart.c fmc.c clk.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM4_Keil.lib
  group Application
    ../Application/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group tslib
    ../tslib/: ts_calibrate.c testutils.c font_8x8.c fbutils.c M48XTouchPanel.c SDGlue.c diskio.c
  group FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group src
    ../: main.c
target emWin_GUIDemo_SD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: as above
  output: emWin_GUIDemo_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USE_SD__
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\tslib;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: as above
