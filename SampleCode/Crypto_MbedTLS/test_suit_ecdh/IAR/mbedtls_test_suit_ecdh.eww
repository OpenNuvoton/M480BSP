<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mbedtls_test_suit_ecdh.ewp</path>
  </project>
  <batchBuild/>
</workspace>


