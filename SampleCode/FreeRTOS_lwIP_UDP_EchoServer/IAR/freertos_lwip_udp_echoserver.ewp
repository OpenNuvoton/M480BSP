# IAR project freertos_lwip_udp_echoserver.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __TARGET_FPU_VFP
  ICCARM.CCDiagSuppress: Pa082,Pe550,Pe177,Pe549
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\include; ..; ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Demo\Common\include; ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F; ..\lwip-2.0.2\port\FreeRTOS\include; ..\..\..\ThirdParty\lwip-2.0.2\src\include\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: RVDS_ARMCM4_NUC4xx; __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\M480\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\Common\include
  OBJCOPY.OOCOutputFile: freertos_lwip_udp_echoserver.bin
  ILINK.IlinkOutputFile: freertos_lwip_udp_echoserver.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP
    ../../../ThirdParty/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../ThirdParty/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../ThirdParty/lwip-2.0.2/src/netif/: ethernet.c
    ../lwip-2.0.2/port/FreeRTOS/netif/: ethernetif.c m480_eth.c
    ../lwip-2.0.2/port/FreeRTOS/: sys_arch.c time_stamp.c
  group User
    ../: main.c udp_echoserver-netconn.c
