# Keil uVision project FreeRTOS_lwIP_UDP_EchoServer.uvproj, settings and files
target FreeRTOS_lwip_UDP_EchoServer (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS_lwip_UDP_EchoServer +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --diag_suppress=550,177,C4017,111
  c include: ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\DEMO\COMMON\include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\;..\..\..\ThirdParty\lwip-2.0.2\src\include;..\lwip-2.0.2\port\FreeRTOS\include;..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c udp_echoserver-netconn.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group lwIP
    ../lwip-2.0.2/port/FreeRTOS/: sys_arch.c time_stamp.c
    ../lwip-2.0.2/port/FreeRTOS/netif/: ethernetif.c m480_eth.c
    ../../../ThirdParty/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../ThirdParty/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../ThirdParty/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip-2.0.2/src/netif/: ethernet.c
