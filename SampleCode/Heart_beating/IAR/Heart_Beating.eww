<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Heart_Beating.ewp</path>
  </project>
  <batchBuild/>
</workspace>


