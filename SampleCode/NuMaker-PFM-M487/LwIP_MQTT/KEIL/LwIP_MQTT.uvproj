# Keil uVision project LwIP_MQTT.uvproj, settings and files
target LwIP_MQTT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: LwIP_MQTT +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx LWIP_ENABLE_CLIENT_CA=1 FREERTOS MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: --diag_suppress=550,177,C4017,111,188
  c include: ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\;..\..\..\..\ThirdParty\lwip\src\include;..\..\lwIP\include;..\..\..\..\Library\CMSIS\Include;..\src\mbedtls_app;..\..\..\..\ThirdParty\mbedtls-2.13.0\include;..\src\mqtt_app;..\src\config;..\..\..\..\ThirdParty\paho.mqtt.embedded-c\MQTTPacket\src;..\..\..\..\ThirdParty\lwIP\src\include\lwip
  asm define: Stack_Size= 0x00001800
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c crypto.c
  group MQTT_App
    ../src/app/: lan.c
    ../src/mbedtls_app/: lwip_tls.c platform_alt.c threading_alt.c
    ../src/mqtt_app/: mqtt-client.c mqtt-tcp.c
  group MQTT
    ../../../../ThirdParty/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c m480_eth.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-2.13.0/library/: aes.c threading.c des.c bignum.c ecdh.c ecp.c ecp_curves.c asn1parse.c asn1write.c ecdsa.c hmac_drbg.c md.c md_wrap.c md5.c ripemd160.c sha1.c sha256.c sha512.c entropy.c entropy_poll.c ssl_tls.c ctr_drbg.c x509_crt.c x509.c debug.c dhm.c ssl_ciphersuites.c pem.c pk.c cipher.c cipher_wrap.c ssl_cli.c oid.c pkparse.c base64.c gcm.c pkcs12.c pk_wrap.c arc4.c rsa.c ssl_srv.c certs.c ccm.c blowfish.c camellia.c timing.c pkcs5.c platform_util.c chacha20.c chachapoly.c rsa_internal.c poly1305.c
