<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LwIP_httpd_netconn.ewp</path>
  </project>
  <batchBuild/>
</workspace>


