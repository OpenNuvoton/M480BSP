# Keil uVision project BLE_2_UART.uvproj, settings and files
target BLE_2_UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: BLE_2_UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TRSPX_DEFAULT_MTU=23 UART_RX_USE_PDMA
  c misc: --diag_suppress=161
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\BLE_AB1602\Library\include
  asm define: Heap_Size=0x1000 Stack_Size=0x400
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ..\..\porting\M487\M487.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c trspx.c trspx_gatt.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c fmc.c gpio.c pdma.c spi.c sys.c timer.c uart.c
  group BLeHal
    ../../porting/M487/: bt_porting_flash.c bt_porting_misc.c bt_porting_mmi_timer.c bt_porting_spi.c
  group BleStack
    ../../../../../ThirdParty/BLE_AB1602/Library/source/blestack/: 1602_patching.c BtCoreM4.lib
  group GattService
    ../../../../../ThirdParty/BLE_AB1602/Library/source/services/: service_trspx.c
