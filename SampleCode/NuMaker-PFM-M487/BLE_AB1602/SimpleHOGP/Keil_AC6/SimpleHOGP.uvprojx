# Keil uVision project SimpleHOGP.uvprojx, settings and files
target SimpleHOGP (6120000::V6.12::.\ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: SimpleHOGP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\BLE_AB1602\Library\include
  asm define: Heap_Size=0x3000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\porting\M487\M487_AC6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c SimpleHOGP_Gatt.c SimpleHOGP_Gap.c SimpleHOGP_Gap_Adv.c SimpleHOGP.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c fmc.c gpio.c pdma.c spi.c sys.c timer.c uart.c
  group BleHal
    ../../porting/M487/: bt_porting_flash.c bt_porting_misc.c bt_porting_mmi_timer.c bt_porting_spi.c
  group BleStack
    ../../../../../ThirdParty/BLE_AB1602/Library/source/blestack/: 1602_patching.c BtCoreM4.lib
  group GattServices
    ../../../../../ThirdParty/BLE_AB1602/Library/source/services/: service_human_interface_device.c service_battery.c service_device_information.c service_generic_access.c service_generic_attribute.c
