# Keil uVision project LwIP_httpd_scoket.uvproj, settings and files
target LwIP_httpd_scoket (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: LwIP_httpd_scoket +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --diag_suppress=550,177,C4017,111
  c include: ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\;..\..\..\..\ThirdParty\lwip\src\include;..\..\lwip\include;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c fs.c httpserver-socket.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c m480_eth.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
