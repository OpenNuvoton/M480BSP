<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LwIP_TCP_EchoServer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


