<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2S_Codec_PDMA.ewp</path>
  </project>
  <batchBuild/>
</workspace>


