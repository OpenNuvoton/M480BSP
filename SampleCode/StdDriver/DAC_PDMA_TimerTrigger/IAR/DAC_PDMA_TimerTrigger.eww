<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DAC_PDMA_TimerTrigger.ewp</path>
  </project>
  <batchBuild/>
</workspace>


