# Keil uVision project EMAC_uIP_telnetd.uvproj, settings and files
target EMAC_uIP_telnetd (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: EMAC_uIP_telnetd
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=177
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\;..\..\..\..\ThirdParty\uip-0.9\uip
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c emac.c clk.c sys.c uart.c timer.c
  group User
    ../: main.c memb.c telnetd.c telnetd-shell.c uip_arch.c
  group uIP
    ../../../../ThirdParty/uip-0.9/uip/: uip.c uip_arp.c
