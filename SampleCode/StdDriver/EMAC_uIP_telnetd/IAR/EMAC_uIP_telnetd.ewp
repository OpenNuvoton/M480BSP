# IAR project EMAC_uIP_telnetd.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..; ..\..\..\..\ThirdParty\uip-0.9\uip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EMAC_uIP_telnetd.bin
  ILINK.IlinkOutputFile: EMAC_uIP_telnetd.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c emac.c retarget.c sys.c timer.c uart.c
  group uIP
    ../../../../ThirdParty/uip-0.9/uip/: uip.c uip_arp.c
  group User
    ../: main.c memb.c telnetd-shell.c telnetd.c uip_arch.c
