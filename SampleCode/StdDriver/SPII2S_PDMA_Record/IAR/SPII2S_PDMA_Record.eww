<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPII2S_PDMA_Record.ewp</path>
  </project>
  <batchBuild/>
</workspace>


