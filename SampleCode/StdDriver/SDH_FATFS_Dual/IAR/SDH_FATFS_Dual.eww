<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SDH_FATFS_Dual.ewp</path>
  </project>
  <batchBuild/>
</workspace>


