<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EADC_Pending_Priority.ewp</path>
  </project>
  <batchBuild/>
</workspace>


