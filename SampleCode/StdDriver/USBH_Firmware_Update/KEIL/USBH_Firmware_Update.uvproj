# Keil uVision project USBH_Firmware_Update.uvproj, settings and files
target USBH_Firmware_Update (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH_Firmware_Update
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\USB_Host\Inc;..\..\..\..\Library\USB_Host\Inc\usb_umas;..\..\..\..\ThirdParty\FatFs\src
  asm define: Stack_Size=0x4000 Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\usbh_firmware_update.sct
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c diskio.c usbh_update.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
  group Lib_USBH_Core
    ../../../../Library/USB_Host/src_core/: urb.c usb.c hcd.c hub.c usb_main.c config.c driver.c endpoint.c message.c generic.c linux_bus_driver.c linux_fake.c support.c
    ../../../../Library/USB_Host/src_core/host/: ehci-hcd.c ohci-hcd.c
  group Lib_USBH_MASS
    ../../../../Library/USB_Host/src_umas/: UmasDebug.c UmasDriver.c UmasProtocol.c UmasScsiGlue.c UmasTransport.c
  group Lib_FATFS
    ../../../../ThirdParty/FatFs/src/: ff.c
