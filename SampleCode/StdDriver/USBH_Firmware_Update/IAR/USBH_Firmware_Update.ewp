# IAR project USBH_Firmware_Update.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\USB_Host\Inc; ..\..\..\..\Library\USB_Host\Inc\usb_umas; ..\..\..\..\ThirdParty\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_Firmware_Update.bin
  ILINK.IlinkOutputFile: USBH_Firmware_Update.out
  ILINK.IlinkIcfFile: .\USBH_Firmware_Update.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Lib_FATFS
    ../../../../ThirdParty/FatFs/src/: ff.c
  group Lib_USBH_Core
    ../../../../Library/USB_Host/src_core/: config.c driver.c endpoint.c generic.c hcd.c hub.c linux_bus_driver.c linux_fake.c message.c support.c urb.c usb.c usb_main.c
    ../../../../Library/USB_Host/src_core/host/: ehci-hcd.c ohci-hcd.c
  group Lib_USBH_Mass
    ../../../../Library/USB_Host/src_umas/: UmasDebug.c UmasDriver.c UmasProtocol.c UmasScsiGlue.c UmasTransport.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c spim.c sys.c uart.c
  group User
    ../: diskio.c main.c usbh_update.c
