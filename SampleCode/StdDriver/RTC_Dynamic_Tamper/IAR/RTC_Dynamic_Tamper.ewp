# IAR project RTC_Dynamic_Tamper.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTC_Dynamic_Tamper.bin
  ILINK.IlinkOutputFile: RTC_Dynamic_Tamper.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c rtc.c sys.c uart.c
  group User
    ../: main.c
