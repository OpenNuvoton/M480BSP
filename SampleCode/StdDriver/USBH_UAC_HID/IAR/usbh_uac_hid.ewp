# IAR project usbh_uac_hid.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USB_MEMORY_POOL_SIZE=0x18000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\USB_Host\Inc; ..\..\..\..\Library\USB_Host\Inc\usb_hid; ..\..\..\..\Library\USB_Host\Inc\usb_uac
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_uac_hid.bin
  ILINK.IlinkOutputFile: usbh_uac_hid.out
  ILINK.IlinkIcfFile: .\usbh_uac_hid.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Lib_USBH_Core
    ../../../../Library/USB_Host/src_core/: config.c driver.c endpoint.c generic.c hcd.c hub.c linux_bus_driver.c linux_fake.c message.c support.c urb.c usb.c usb_main.c
    ../../../../Library/USB_Host/src_core/host/: ehci-hcd.c ohci-hcd.c
  group Lib_USBH_HID
    ../../../../Library/USB_Host/src_hid/: hid_core.c hid_driver.c
  group Lib_USBH_UAC
    ../../../../Library/USB_Host/src_uac/: uac_core.c uac_driver.c uac_parser.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spim.c sys.c uart.c
  group User
    ../: main.c
