<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HSUSBH_USBH_HID_Mouse_Keyboard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


