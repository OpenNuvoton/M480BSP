<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2s_mp3player.ewp</path>
  </project>
  <batchBuild/>
</workspace>



