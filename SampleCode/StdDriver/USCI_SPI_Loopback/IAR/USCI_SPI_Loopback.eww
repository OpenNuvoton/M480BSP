<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USCI_SPI_Loopback.ewp</path>
  </project>
  <batchBuild/>
</workspace>


