<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_Audio_NAU88L25.ewp</path>
  </project>
  <batchBuild/>
</workspace>


