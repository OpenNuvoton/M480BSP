<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HSUSBH_USBH_Firmware_Update.ewp</path>
  </project>
  <batchBuild/>
</workspace>


