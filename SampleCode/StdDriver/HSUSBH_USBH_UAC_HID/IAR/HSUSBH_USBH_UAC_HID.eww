<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HSUSBH_USBH_UAC_HID.ewp</path>
  </project>
  <batchBuild/>
</workspace>


