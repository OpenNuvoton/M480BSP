# Keil uVision project mbedtls_test_suit_ecdsa.uvproj, settings and files
target mbedtls_ecdsa_test_suit (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: mbedtls_ecdsa_test_suit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\mbedtls-2.6.0\include
  asm define: Stack_Size=0x1000 Heap_Size=0x4000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c
    ./: vector_data.s
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crypto.c retarget.c sys.c uart.c
  group Mbedtls Library
    ../../../../../ThirdParty/mbedtls-2.6.0/library/: asn1parse.c asn1write.c bignum.c ecp.c ecp_curves.c ecdsa.c hmac_drbg.c md.c md_wrap.c md5.c ripemd160.c sha1.c sha256.c sha512.c
