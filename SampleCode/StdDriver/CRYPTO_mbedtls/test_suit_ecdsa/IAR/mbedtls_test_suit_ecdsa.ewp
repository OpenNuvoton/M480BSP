# IAR project mbedtls_test_suit_ecdsa.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\mbedtls-2.6.0\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mbedtls_test_suit_ecdsa.bin
  ILINK.IlinkOutputFile: mbedtls_test_suit_ecdsa.out
  ILINK.IlinkIcfFile: mbedtls_test_suit_ecdsa
  ILINK.IlinkExtraOptions: --image_input ..\test_suite_ecdsa.data,VectorBase_ECDSA,.bin_image,4; --image_input ..\test_suite_ecdsa.data,VectorLimit_ECDSA,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crypto.c retarget.c sys.c uart.c
  group Mbedtls Library
    ../../../../../ThirdParty/mbedtls-2.6.0/library/: asn1parse.c asn1write.c bignum.c ecdsa.c ecp.c ecp_curves.c hmac_drbg.c md.c md5.c md_wrap.c ripemd160.c sha1.c sha256.c sha512.c
  group User
    ../: main.c
