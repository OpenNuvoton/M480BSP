# IAR project mbedtls_test_suit_aes.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\ThirdParty\mbedtls-2.6.0\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mbedtls_test_suit_aes.bin
  ILINK.IlinkOutputFile: mbedtls_test_suit_aes.out
  ILINK.IlinkIcfFile: mbedtls_test_suit_aes
  ILINK.IlinkExtraOptions: --image_input ..\test_suite_aes.cbc.data,VectorBase_CBC,.bin_image,4; --image_input ..\test_suite_aes.cbc.data,VectorLimit_CBC,.bin_image,4; --image_input ..\test_suite_aes.cbc.data,VectorBase_CFB,.bin_image,4; --image_input ..\test_suite_aes.cbc.data,VectorLimit_CFB,.bin_image,4; --image_input ..\test_suite_aes.cbc.data,VectorBase_ECB,.bin_image,4; --image_input ..\test_suite_aes.cbc.data,VectorLimit_ECB,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c crypto.c retarget.c sys.c uart.c
  group Mbedtls Library
    ../../../../../ThirdParty/mbedtls-2.6.0/library/: aes.c
  group User
    ../: main.c
