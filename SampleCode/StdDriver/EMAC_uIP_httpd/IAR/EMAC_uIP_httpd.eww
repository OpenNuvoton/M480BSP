<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EMAC_uIP_httpd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


