<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OTG_Dual_Role_UMAS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


