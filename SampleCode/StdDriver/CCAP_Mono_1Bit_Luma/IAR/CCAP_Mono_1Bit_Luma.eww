<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CCAP_Mono_1Bit_Luma.ewp</path>
  </project>
  <batchBuild/>
</workspace>


