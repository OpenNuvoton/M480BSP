<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HSUSBD_Mass_Storage_SRAM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


