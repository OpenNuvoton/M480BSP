<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\qspi_dualmode_flash.ewp</path>
  </project>
  <batchBuild/>
</workspace>


