<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_VCOM_And_HID_Keyboard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


