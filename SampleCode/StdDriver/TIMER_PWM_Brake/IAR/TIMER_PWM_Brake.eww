<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIMER_PWM_Brake.ewp</path>
  </project>
  <batchBuild/>
</workspace>


