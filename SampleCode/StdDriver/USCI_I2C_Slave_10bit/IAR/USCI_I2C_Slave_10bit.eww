<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USCI_I2C_Slave_10bit.ewp</path>
  </project>
  <batchBuild/>
</workspace>


