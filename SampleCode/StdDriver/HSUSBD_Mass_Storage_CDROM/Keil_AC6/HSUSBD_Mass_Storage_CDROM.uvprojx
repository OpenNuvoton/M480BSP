# Keil uVision project HSUSBD_Mass_Storage_CDROM.uvprojx, settings and files
target HSUSBD_Mass_Storage_CDROM (6120000::V6.12::.\ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_Mass_Storage_CDROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c descriptors.c MassStorage.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c
  group DisjImage
    ../: diskimage.c
