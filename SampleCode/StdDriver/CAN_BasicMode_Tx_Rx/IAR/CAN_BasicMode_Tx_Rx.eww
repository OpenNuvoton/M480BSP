<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CAN_BasicMode_Tx_Rx.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build FMC Sample Code</name>
      <member>
        <project>FMC</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


