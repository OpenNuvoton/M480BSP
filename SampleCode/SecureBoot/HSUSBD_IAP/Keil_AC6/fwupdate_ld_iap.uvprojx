# Keil uVision project fwupdate_ld_iap.uvprojx, settings and files
target fwupdate_ld_iap (6150000::V6.15::ARMCLANG)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: fwupdate_ld_iap
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\FWUpdate
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: fwupdate_ld_iap.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
    ../../../../Library/FWUpdate/: BootIspLib_Keil.lib
