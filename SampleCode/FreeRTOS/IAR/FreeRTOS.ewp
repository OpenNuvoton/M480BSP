# IAR project FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: RVDS_ARMCM4_NUC4xx; __TARGET_FPU_VFP
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\M480\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Demo\Common\include; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: RVDS_ARMCM4_NUC4xx; __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\NUC472_442\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\
  OBJCOPY.OOCOutputFile: FreeRTOS.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Demo/Common/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c
