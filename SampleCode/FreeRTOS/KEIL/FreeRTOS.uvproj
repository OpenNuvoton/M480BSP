# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c flash.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
